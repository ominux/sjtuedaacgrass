A pmos input folded cascode cmos OPAMP.

*m1 small signal model
gm1 16 13 5 13 9.340000e-04
gmb1 16 13 0 13 7.120000e-05
rds1 16 13 3.154574e+04
cdb1 16 0 4.290000e-14
csb1 13 0 3.400000e-14
cgb1 5 0 5.950000e-16
cgd1 5 16 6.710000e-15
cgs1 5 13 2.420000e-13

*m3 small signal model
gm3 16 0 12 0 4.600000e-03
*gmb3 16 0 0 0 2.100000e-03
rds3 16 0 1.290323e+04
cdb3 16 0 7.170000e-13
*csb3 0 0 1.110000e-12
cgb3 12 0 6.560000e-16
cgd3 12 16 3.310000e-14
cgs3 12 0 9.040000e-13

*m2 small signal model
gm2 17 13 0 13 9.340000e-04
gmb2 17 13 0 13 7.120000e-05
rds2 17 13 3.154574e+04
cdb2 17 0 2.460000e-14
csb2 13 0 3.400000e-14
*cgb2 0 0 5.950000e-16
cgd2 0 17 6.710000e-15
cgs2 0 13 2.420000e-13

*m4 small signal model
gm4 17 0 12 0 4.600000e-03
*gmb4 17 0 0 0 2.100000e-03
rds4 17 0 1.291990e+04
cdb4 17 0 3.880000e-13
*csb4 0 0 1.110000e-12
cgb4 12 0 6.560000e-16
cgd4 12 17 3.310000e-14
cgs4 12 0 9.040000e-13

*mN small signal model
gmN 15 16 11 16 2.480000e-03
gmbN 15 16 0 16 5.240000e-04
rdsN 15 16 2.666667e+04
cdbN 15 0 1.710000e-13
csbN 16 0 2.460000e-13
cgbN 11 0 6.560000e-16
cgdN 11 15 1.650000e-14
cgsN 11 16 4.520000e-13

*m8 small signal model
gm8 15 18 10 18 1.470000e-03
gmb8 15 18 0 18 1.210000e-04
rds8 15 18 2.923977e+04
cdb8 15 0 6.830000e-14
csb8 18 0 1.520000e-13
cgb8 10 0 5.950000e-16
cgd8 10 15 1.680000e-14
cgs8 10 18 6.060000e-13

*m10 small signal model
gm10 18 0 14 0 1.400000e-03
*gmb10 18 0 0 0 2.150000e-04
rds10 18 0 2.994012e+04
cdb10 18 0 1.520000e-13
*csb10 0 0 1.750000e-13
cgb10 14 0 5.950000e-16
cgd10 14 18 1.680000e-14
cgs10 14 0 6.060000e-13

*m11 small signal model
gm11 19 0 14 0 1.400000e-03
*gmb11 19 0 0 0 2.150000e-04
rds11 19 0 2.994012e+04
cdb11 19 0 8.720000e-14
*csb11 0 0 1.750000e-13
cgb11 14 0 5.950000e-16
cgd11 14 19 1.680000e-14
cgs11 14 0 6.060000e-13

*m7 small signal model
gm7 16 12 16 12 1.240000e-04
gmb7 16 12 0 12 3.420000e-05
rds7 16 12 3.311258e+05
cdb7 16 0 3.600000e-14
csb7 12 0 4.790000e-14
cgb7 16 0 3.090000e-16
*cgd7 16 16 1.100000e-15
cgs7 16 12 1.480000e-14

CP 10 16 1.05904e-15

*mP small signal model
gmP 10 0 10 0 1.290000e-04
*gmbP 10 0 0 0 1.220000e-05
rdsP 10 0 2.564103e+05
cdbP 10 0 9.480000e-15
*csbP 0 0 2.180000e-14
cgbP 10 0 1.220000e-15
*cgdP 10 10 1.170000e-15
cgsP 10 0 8.540000e-14

*C6 10 17  1.05904e-15

*m12 small signal model
gm12 17 12 17 12 1.260000e-04
gmb12 17 12 0 12 3.490000e-05
rds12 17 12 3.205128e+05
cdb12 17 0 3.590000e-14
csb12 12 0 4.790000e-14
cgb12 17 0 3.090000e-16
*cgd12 17 17 1.100000e-15
cgs12 17 12 1.480000e-14

*m9 small signal model
gm9 7 19 10 19 1.460000e-03
gmb9 7 19 0 19 1.200000e-04
rds9 7 19 2.898551e+04
cdb9 7 0 6.990000e-14
csb9 19 0 1.520000e-13
cgb9 10 0 5.950000e-16
cgd9 10 7 1.680000e-14
cgs9 10 19 6.060000e-13

*m13 small signal model
gm13 9 0 9 0 1.970000e-04
*gmb13 9 0 0 0 2.600000e-05
rds13 9 0 2.994012e+05
cdb13 9 0 3.160000e-14
*csb13 0 0 3.520000e-14
cgb13 9 0 1.220000e-15
*cgd13 9 9 3.360000e-15
cgs13 9 0 2.430000e-13

*m5 small signal model
gm5 13 0 9 0 1.890000e-03
*gmb5 13 0 0 0 2.490000e-04
rds5 13 0 3.205128e+04
cdb5 13 0 1.590000e-13
*csb5 0 0 5.740000e-13
cgb5 9 0 1.220000e-15
cgd5 9 13 3.190000e-14
cgs5 9 0 2.310000e-12

*m14 small signal model
gm14 11 0 9 0 2.120000e-04
*gmb14 11 0 0 0 2.760000e-05
rds14 11 0 3.215434e+05
cdb14 11 0 2.300000e-14
*csb14 0 0 3.520000e-14
cgb14 9 0 1.220000e-15
cgd14 9 11 3.360000e-15
cgs14 9 0 2.430000e-13

*m6 small signal model
gm6 7 17 11 17 2.500000e-03
gmb6 7 17 0 17 5.270000e-04
rds6 7 17 2.857143e+04
cdb6 7 0 1.650000e-13
csb6 17 0 2.460000e-13
cgb6 11 0 6.560000e-16
cgd6 11 7 1.650000e-14
cgs6 11 17 4.510000e-13

*m16 small signal model
gm16 11 0 11 0 9.430000e-05
*gmb16 11 0 0 0 2.090000e-05
rds16 11 0 2.762431e+05
cdb16 11 0 1.580000e-14
*csb16 0 0 6.970000e-14
cgb16 11 0 1.350000e-15
*cgd16 11 11 6.610000e-16
cgs16 11 0 3.650000e-14

*m15 small signal model
gm15 12 9 0 9 4.540000e-05
gmb15 12 9 0 9 2.620000e-06
rds15 12 9 7.692308e+05
cdb15 12 0 2.910000e-15
csb15 9 0 4.370000e-15
*cgb15 0 0 2.270000e-15
cgd15 0 12 4.190000e-16
cgs15 0 9 5.660000e-14

*m17 small signal model
gm17 12 0 12 0 5.820000e-04
*gmb17 12 0 0 0 2.670000e-04
rds17 12 0 6.802721e+04
cdb17 12 0 1.330000e-13
*csb17 0 0 1.600000e-13
cgb17 12 0 6.560000e-16
*cgd17 12 12 4.410000e-15
cgs17 12 0 1.200000e-13

*m18 small signal model
gm18 10 0 12 0 6.970000e-04
*gmb18 10 0 0 0 3.120000e-04
rds18 10 0 1.449275e+05
cdb18 10 0 6.200000e-14
*csb18 0 0 1.600000e-13
cgb18 12 0 6.560000e-16
cgd18 12 10 4.410000e-15
cgs18 12 0 1.200000e-13

*m19 small signal model
gm19 0 14 15 14 1.330000e-03
gmb19 0 14 0 14 1.030000e-04
rds19 0 14 2.044990e+04
*cdb19 0 0 2.840000e-14
csb19 14 0 8.680000e-14
cgb19 15 0 9.050000e-16
cgd19 15 0 8.390000e-15
cgs19 15 14 4.560000e-13

*m20 small signal model
gm20 14 0 14 0 4.220000e-03
*gmb20 14 0 0 0 6.470000e-04
rds20 14 0 4.347826e+03
cdb20 14 0 1.870000e-13
*csb20 0 0 3.260000e-13
cgb20 14 0 2.850000e-16
*cgd20 14 14 2.520000e-14
cgs20 14 0 4.470000e-13

C1 5 0 1.9857e-15
C2 16 0 6.5607e-15

CGB 11 0 7.80378e-15
CGD 11 15 4.13687e-15
C3 11 0 7.80378e-15
C4 11 7 4.13687e-15
*CP 10 16 1.05904e-15
C5 16 0 3.19403e-15
*C6 10 17  1.05904e-15
C7 17 0 3.19403e-15
C8 10 0 6.73335e-15
C9 11 0 6.73335e-15
C10 12 0 3.97095e-15
C11 14 0 5.1795e-15

*.EQUIV AVdd = 3
*.EQUIV AVss = 4
*.EQUIV Non = 5
*.EQUIV Inv = 6
*.EQUIV Out = 7

*positive input is 5
*negative input is grounded
*output is 7
*VIN1 5 0 DC -.2834M AC 1

vin 5 0 ac 1

*.AC DEC 10 1 200meg
*.AC V(5) DEC 10 1 200meg
.ac lin 9 1k 9k
.print ac vm(7)
.end
