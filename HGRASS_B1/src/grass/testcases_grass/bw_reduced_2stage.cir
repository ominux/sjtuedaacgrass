* Design project of ampilifier library define

VIN 13 0 ac 1

Cl 20 0 10p

Cc 15 20 2.2p

Rb 11 15 3.5k

* definition of MOSFET: d g s b p/nch3 W L-----

* M1 3 13 7 7 pch3 W=200u L=0.35u
rd_1 3 100 7.2000m
rs_1 7 101 7.2000m
capbd_1 100 7 174.5415f
capbs_1 101 7 174.5415f
gm_1 100 101 13 7 965.1864u
rds_1 100 101 261451.579168
cgs_1 13 101 148.5920f
cgd_1 13 100 55.3264f

* M2 4 14 7 7 pch3 W=200u L=0.35u
rd_2 4 102 7.2000m
rs_2 7 103 7.2000m
capbd_2 102 7 174.5415f
capbs_2 103 7 174.5415f
gm_2 102 103 0 7 942.0467u
rds_2 102 103 267372.530146
cgs_2 0 103 146.9087f
cgd_2 0 102 55.3276f

* M3 5 13 8 gnd nch3 W=19u L=0.35u *50uA 20um
rd_3 5 104 71.5789m
rs_3 8 105 71.5789m
capbd_3 104 0 17.4890f
capbs_3 105 0 17.4890f
gm_3 104 105 13 8 806.3797u
rds_3 104 105 64709.422339
gmb_3 104 105 0 8 182.9343u
cgs_3 13 105 13.8807f
cgd_3 13 104 5.9521f

* M4 6 14 8 gnd nch3 W=19u L=0.35u
rd_4 6 106 71.5789m
rs_4 8 107 71.5789m
capbd_4 106 0 17.4890f
capbs_4 107 0 17.4890f
gm_4 106 107 0 8 820.4943u
rds_4 106 107 63600.6894315
gmb_4 106 107 0 8 186.1812u
cgs_4 0 107 14.0109f
cgd_4 0 106 5.9507f

* M5 9 9 vdd vdd pch3 W=4u L=0.35u
rd_5 9 108 360.0000m
rs_5 0 109 360.0000m
capbd_5 108 0 3.6658f
capbs_5 109 0 3.6658f
gm_5 108 109 9 0 248.7007u
rds_5 108 109 231561.884914
cgs_5 9 109 5.0105f
cgd_5 9 108 1.0949f

* M6 3 10 gnd gnd nch3 W=60u L=0.35u
rd_6 3 110 22.6667m
rs_6 0 111 22.6667m
capbd_6 110 0 54.7957f
capbs_6 111 0 54.7957f
gm_6 110 111 10 0 2.4255m
rds_6 110 111 7438.4948057
cgs_6 10 111 50.4951f
cgd_6 10 110 19.1399f

* M7 4 10 gnd gnd nch3 W=60u L=0.35u
rd_7 4 112 22.6667m
rs_7 0 113 22.6667m
capbd_7 112 0 54.7957f
capbs_7 113 0 54.7957f
gm_7 112 113 10 0 2.3827m
rds_7 112 113 6452.50376504
cgs_7 10 113 50.5144f
cgd_7 10 112 19.1923f

* M8 vout 11 vdd vdd pch3 W=120u L=0.35u
rd_8 20 114 12.0000m
rs_8 0 115 12.0000m
capbd_8 114 0 104.7963f
capbs_8 115 0 104.7963f
gm_8 114 115 11 0 1.5799m
rds_8 114 115 135630.001356
cgs_8 11 115 128.5040f
cgd_8 11 114 33.1666f

* M9 11 9 5 vdd pch3 W=45u L=0.35u
rd_9 11 116 32.0000m
rs_9 5 117 32.0000m
capbd_9 116 0 39.4102f
capbs_9 117 0 39.4102f
gm_9 116 117 9 5 1.0804m
rds_9 116 117 72577.894225
gmb_9 116 117 0 5 497.0398u
cgs_9 9 117 53.5515f
cgd_9 9 116 12.4399f

* M10 10 9 6 vdd pch3 W=45u L=0.35u
rd_10 10 118 32.0000m
rs_10 6 119 32.0000m
capbd_10 118 0 39.4102f
capbs_10 119 0 39.4102f
gm_10 118 119 9 6 1.1121m
rds_10 118 119 184508.653456
gmb_10 118 119 0 6 505.9506u
cgs_10 9 119 53.1444f
cgd_10 9 118 12.4114f

* M11 11 12 3 gnd nch3 W=50u L=0.35u
rd_11 11 120 27.2000m
rs_11 3 121 27.2000m
capbd_11 120 0 45.6965f
capbs_11 121 0 45.6965f
gm_11 120 121 12 3 1.7913m
rds_11 120 121 44761.3548367
gmb_11 120 121 0 3 629.4196u
cgs_11 12 121 33.7936f
cgd_11 12 120 15.8118f

* M12 10 12 4 gnd nch3 W=50u L=0.35u
rd_12 10 122 27.2000m
rs_12 4 123 27.2000m
capbd_12 122 0 45.6965f
capbs_12 123 0 45.6965f
gm_12 122 123 12 4 1.7870m
rds_12 122 123 35006.2836279
gmb_12 122 123 0 4 662.2016u
cgs_12 12 123 36.8268f
cgd_12 12 122 15.8035f

* M13 12 12 gnd gnd nch3 W=5u L=0.35u
rd_13 12 124 272.0000m
rs_13 0 125 272.0000m
capbd_13 124 0 4.7501f
capbs_13 125 0 4.7501f
gm_13 124 125 12 0 789.0159u
rds_13 124 125 78485.542963
cgs_13 12 125 5.3996f
cgd_13 12 124 1.5690f

* netlist options---------------------

.options list node post=2 unwrapp probe

*analysis-------------------------------

.op

.ac dec 100 1 1g

.print ac  VDB(20) VP(20)

.END
