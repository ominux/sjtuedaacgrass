* Design project of ampilifier library define1
**Vin (7)

VIN 7 0 ac 1

*****************************************
**order1
* M10 13 13 vdd vdd pch3 W=4u L=0.35u
rd_10 13 118 360.0000m
rs_10 0 119 360.0000m
capbd_10 118 0 3.6658f
capbs_10 119 0 3.6658f
gm_10 118 119 13 0 248.7222u
rds_10 118 119 231524.356362
cgs_10 13 119 5.0105f
cgd_10 13 118 1.0949f

* M22 13 15 gnd gnd nch3 W=39u L=1u
rd_22 13 142 34.8718m
rs_22 0 143 34.8718m
capbd_22 142 0 35.6874f
capbs_22 143 0 35.6874f
gm_22 142 143 15 0 954.3901u
rds_22 142 143 766459.722542
cgs_22 15 143 114.5724f
cgd_22 15 142 12.3713f

**order2
* M19 2 13 7 vdd pch3 W=45u L=0.35u
rd_19 2 136 32.0000m
rs_19 7 137 32.0000m
capbd_19 136 0 39.4102f
capbs_19 137 0 39.4102f
gm_19 136 137 13 7 1.0804m
rds_19 136 137 75115.1139121
gmb_19 136 137 0 7 496.9157u
cgs_19 13 137 53.5370f
cgd_19 13 136 12.4366f

**order3
* M20 6 13 8 vdd pch3 W=45u L=0.35u
rd_20 6 138 32.0000m
rs_20 8 139 32.0000m
capbd_20 138 0 39.4102f
capbs_20 139 0 39.4102f
gm_20 138 139 13 8 1.1079m
rds_20 138 139 185763.114876
gmb_20 138 139 0 8 503.8543u
cgs_20 13 139 53.1216f
cgd_20 13 138 12.4114f

**order7
* M16 vout 2 vdd vdd pch3 W=120u L=0.35u
rd_16 20 130 12.0000m
rs_16 0 131 12.0000m
capbd_16 130 0 104.7963f
capbs_16 131 0 104.7963f
gm_16 130 131 2 0 1.6749m
rds_16 130 131 20978.6542193
cgs_16 2 131 133.6542f
cgd_16 2 130 33.8129f

Cl 20 0 10p
Cc 9 20 2.2p
Rb 2 9 3.5k
l1 10 20 1g

**order8
* M15 vout 15 gnd gnd nch3 W=10u L=0.35u
rd_15 20 128 136.0000m
rs_15 0 129 136.0000m
capbd_15 128 0 9.2997f
capbs_15 129 0 9.2997f
gm_15 128 129 15 0 1.1862m
rds_15 128 129 63043.7523641
cgs_15 15 129 10.2317f
cgd_15 15 128 3.1480f

**order9
*analysis-------------------------------
.op
.ac dec 100 1 1g
.print ac vm(20)
.END
