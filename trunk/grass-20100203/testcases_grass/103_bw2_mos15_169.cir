*3stage OPAMP after extraction

VIN 13 0 ac 1

* the third CS stage

* M11 vout 4 vdd vdd pch3 L=0.5u W=80u
rd_11 15 120 18.0000m
rs_11 0 121 18.0000m
capbd_11 120 0 69.9237f
capbs_11 121 0 69.9237f
gm_11 120 121 4 0 3.4662m
rds_11 120 121 28002.1841704
cgs_11 4 121 150.1205f
cgd_11 4 120 22.1456f

* compensation capacitors
Cc1 4 10 5p
Cc2 7 11 20p
Rc1 10 15 600
Rc2 11 10 5
* load capacitor
l 15 0 30p

* M12 vout 7 gnd gnd nch3 L=0.5u W=6.5u
rd_12 15 122 209.2308m
rs_12 0 123 209.2308m
capbd_12 122 0 6.1150f
capbs_12 123 0 6.1150f
gm_12 122 123 7 0 1.3692m
rds_12 122 123 34346.4387895
cgs_12 7 123 11.7976f
cgd_12 7 122 2.0581f

* the second stage

* M15 9 9 vdd vdd pch3 L=0.5u W=1.15u
rd_15 9 128 1.2522
rs_15 0 129 1.2522
capbd_15 128 0 1.1811f
capbs_15 129 0 1.1811f
gm_15 128 129 9 0 47.3018u
rds_15 128 129 1774228.37477
cgs_15 9 129 2.0958f
cgd_15 9 128 3.074756e-16

* M7 7 9 5 5 pch3 L=0.5u W=60u
rd_7 7 112 24.0000m
rs_7 5 113 24.0000m
capbd_7 112 5 52.4874f
capbs_7 113 5 52.4874f
gm_7 112 113 9 5 310.0655u
rds_7 112 113 45221.2449409
cgs_7 9 113 85.9741f
cgd_7 9 112 17.6555f

* M9 7 6 gnd gnd nch3 L=0.5u W=8u
rd_9 7 116 170.0000m
rs_9 0 117 170.0000m
capbd_9 116 0 7.4799f
capbs_9 117 0 7.4799f
gm_9 116 117 6 0 295.0306u
rds_9 116 117 1274764.85687
cgs_9 6 117 10.9092f
cgd_9 6 116 2.5261f

* M8 6 6 gnd gnd nch3 L=0.5u W=8u
rd_8 6 114 170.0000m
rs_8 0 115 170.0000m
capbd_8 114 0 7.4799f
capbs_8 115 0 7.4799f
gm_8 114 115 6 0 284.2360u
rds_8 114 115 1022054.60981
cgs_8 6 115 10.8566f
cgd_8 6 114 2.5266f

* M6 6 4 5 5 pch3 L=0.5u W=60u
rd_6 6 110 24.0000m
rs_6 5 111 24.0000m
capbd_6 110 5 52.4874f
capbs_6 111 5 52.4874f
gm_6 110 111 4 5 314.0341u
rds_6 110 111 1593477.70454
cgs_6 4 111 81.7473f
cgd_6 4 110 16.5970f

* M10 5 8 vdd vdd pch3 L=0.5u W=80u
rd_10 5 118 18.0000m
rs_10 0 119 18.0000m
capbd_10 118 0 69.9237f
capbs_10 119 0 69.9237f
gm_10 118 119 8 0 574.6438u
rds_10 118 119 433012.903785
cgs_10 8 119 121.8909f
cgd_10 8 118 22.1475f

* M14 8 8 vdd vdd pch3 L=0.5u W=10u
rd_14 8 126 144.0000m
rs_14 0 127 144.0000m
capbd_14 126 0 8.8966f
capbs_14 127 0 8.8966f
gm_14 126 127 8 0 72.2754u
rds_14 126 127 4371072.59128
cgs_14 8 127 15.1807f
cgd_14 8 126 2.7575f

* the first differential input stage

**order2
* M2 4 13 2 2 nch3 L=0.5u W=8u
rd_2 4 102 170.0000m
rs_2 2 103 170.0000m
capbd_2 102 2 7.4799f
capbs_2 103 2 7.4799f
gm_2 102 103 13 2 397.8516u
rds_2 102 103 734268.301637
cgs_2 13 103 11.9063f
cgd_2 13 102 2.5256f

**order4
* M4 4 3 vdd vdd pch3 L=0.5u W=2u
rd_4 4 106 720.0000m
rs_4 0 107 720.0000m
capbd_4 106 0 1.9221f
capbs_4 107 0 1.9221f
gm_4 106 107 3 0 84.0566u
rds_4 106 107 1033911.04147
cgs_4 3 107 3.6908f
cgd_4 3 106 5.429304e-16

**order3
* M3 3 3 vdd vdd pch3 L=0.5u W=2u
rd_3 3 104 720.0000m
rs_3 0 105 720.0000m
capbd_3 104 0 1.9221f
capbs_3 105 0 1.9221f
gm_3 104 105 3 0 84.0722u
rds_3 104 105 1039610.94432
cgs_3 3 105 3.6908f
cgd_3 3 104 5.429223e-16

**order1
* M1 3 12 2 2 nch3 L=0.5u W=8u
rd_1 3 100 170.0000m
rs_1 2 101 170.0000m
capbd_1 100 2 7.4799f
capbs_1 101 2 7.4799f
gm_1 100 101 0 2 397.8797u
rds_1 100 101 731903.681476
cgs_1 0 101 11.9069f
cgd_1 0 100 2.5256f

**order5
* M5 2 1 gnd gnd nch3 L=0.5u W=25u
rd_5 2 108 54.4000m
rs_5 0 109 54.4000m
capbd_5 108 0 22.9485f
capbs_5 109 0 22.9485f
gm_5 108 109 1 0 909.7460u
rds_5 108 109 183725.587463
cgs_5 1 109 34.4548f
cgd_5 1 108 7.9234f

**order6
* M13 1 1 gnd gnd nch3 L=0.5u W=2u
rd_13 1 124 680.0000m
rs_13 0 125 680.0000m
capbd_13 124 0 2.0204f
capbs_13 125 0 2.0204f
gm_13 124 125 1 0 73.1612u
rds_13 124 125 3736599.61961
cgs_13 1 125 2.7417f
cgd_13 1 124 6.244559e-16

**order7

.options list node post=2 unwrapp probe

.op

.ac dec 10 1 1g

.print ac VDB(15)

.END
