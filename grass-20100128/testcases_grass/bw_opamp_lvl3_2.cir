*Three-stage opamp BW    *title

*Ibias1 11 1 dc 5u

*Ibias2 8 0 dc 5u

*Ibias3 9 0 dc 18u

* the first differential input stage

* M1 3 13 2 2 n L=0.5u W=8u
gm_1 3 2 13 2 559.5975u
rds_1 3 2 359414.872587
*gmb_1 3 2 2 2 0
cgs_1 13 2 38.0870f
cgd_1 13 3 3.1761f
*cbd_1 100 2 0
*cbs_1 101 2 0
*rd_1 3 100 0
*rs_1 2 101 0

* M2 4 14 2 2 n L=0.5u W=8u
gm_2 4 2 14 2 559.4872u
rds_2 4 2 359492.396736
*gmb_2 4 2 2 2 0
cgs_2 14 2 38.0870f
cgd_2 14 4 3.1772f
*cbd_2 102 2 0
*cbs_2 103 2 0
*rd_2 4 102 0
*rs_2 2 103 0

* M3 3 3 11 11 p L=0.5u W=2u
gm_3 3 11 3 11 169.9084u
rds_3 3 11 1121480.31813
*gmb_3 3 11 11 11 0
cgs_3 3 11 9.5218f
*cgd_3 3 3 7.872809e-08
*cbd_3 104 11 0
*cbs_3 105 11 0
*rd_3 3 104 0
*rs_3 11 105 0

* M4 4 3 11 11 p L=0.5u W=2u
gm_4 4 11 3 11 169.8726u
rds_4 4 11 1121733.42813
*gmb_4 4 11 11 11 0
cgs_4 3 11 9.5218f
cgd_4 3 4 7.869957e-08
*cbd_4 106 11 0
*cbs_4 107 11 0
*rd_4 4 106 0
*rs_4 11 107 0

* M5 2 1 0 0 n L=0.5u W=25u
gm_5 2 0 1 0 1.4174m
rds_5 2 0 142494.79894
*gmb_5 2 0 0 0 0
cgs_5 1 0 119.0219f
cgd_5 1 2 9.8615f
*cbd_5 108 0 0
*cbs_5 109 0 0
*rd_5 2 108 0
*rs_5 0 109 0

* the second stage

* M6 6 4 5 5 p L=0.5u W=60u
gm_6 6 5 4 5 333.8199u
rds_6 6 5 608420.540277
*gmb_6 6 5 5 5 0
cgs_6 4 5 285.6526f
cgd_6 4 6 24.2528f
*cbd_6 110 5 0
*cbs_6 111 5 0
*rd_6 6 110 0
*rs_6 5 111 0

* M7 7 9 5 5 p L=0.5u W=60u
gm_7 7 5 9 5 366.1174u
rds_7 7 5 554754.24387
*gmb_7 7 5 5 5 0
cgs_7 9 5 285.6526f
cgd_7 9 7 23.8198f
*cbd_7 112 5 0
*cbs_7 113 5 0
*rd_7 7 112 0
*rs_7 5 113 0

* M8 6 6 0 0 n L=0.5u W=8u
gm_8 6 0 6 0 429.4046u
rds_8 6 0 470809.792844
*gmb_8 6 0 0 0 0
cgs_8 6 0 38.0870f
*cgd_8 6 6 3.1305f
*cbd_8 114 0 0
*cbs_8 115 0 0
*rd_8 6 114 0
*rs_8 0 115 0

* M9 7 6 0 0 n L=0.5u W=8u
gm_9 7 0 6 0 448.8049u
rds_9 7 0 450105.774857
*gmb_9 7 0 0 0 0
cgs_9 6 0 38.0870f
cgd_9 6 7 3.1882f
*cbd_9 116 0 0
*cbs_9 117 0 0
*rd_9 7 116 0
*rs_9 0 117 0

* M10 5 8 11 11 p L=0.5u W=80u
gm_10 5 11 8 11 1.3636m
rds_10 5 11 149133.534166
*gmb_10 5 11 11 11 0
cgs_10 8 11 380.8701f
cgd_10 8 5 31.1667f
*cbd_10 118 11 0
*cbs_10 119 11 0
*rd_10 5 118 0
*rs_10 11 119 0

* the third CS stage

* M11 12 4 11 11 p L=0.5u W=80u
gm_11 12 11 4 11 6.6085m
rds_11 12 11 28955.1253467
*gmb_11 12 11 11 11 0
cgs_11 4 11 380.8701f
cgd_11 4 12 31.9295f
*cbd_11 120 11 0
*cbs_11 121 11 0
*rd_11 12 120 0
*rs_11 11 121 0

* M12 12 7 0 0 n L=0.5u W=6.5u
gm_12 12 0 7 0 2.2057m
rds_12 12 0 68377.0034462
*gmb_12 12 0 0 0 0
cgs_12 7 0 30.9457f
cgd_12 7 12 2.5943f
*cbd_12 122 0 0
*cbs_12 123 0 0
*rd_12 12 122 0
*rs_12 0 123 0

* bais current branches

* M13 1 1 0 0 n L=0.5u W=2u
gm_13 1 0 1 0 111.3073u
rds_13 1 0 1815148.86943
*gmb_13 1 0 0 0 0
cgs_13 1 0 9.5218f
*cgd_13 1 1 7.826863e-08
*cbd_13 124 0 0
*cbs_13 125 0 0
*rd_13 1 124 0
*rs_13 0 125 0

* M14 8 8 11 11 p L=0.5u W=10u
gm_14 8 11 8 11 172.8740u
rds_14 8 11 1176160.22031
*gmb_14 8 11 11 11 0
cgs_14 8 11 47.6088f
*cgd_14 8 8 3.9108f
*cbd_14 126 11 0
*cbs_14 127 11 0
*rd_14 8 126 0
*rs_14 11 127 0

* M15 9 9 11 11 p L=0.5u W=1.15u
gm_15 9 11 9 11 96.1888u
rds_15 9 11 1985119.5439
*gmb_15 9 11 11 11 0
cgs_15 9 11 5.4750f
*cgd_15 9 9 4.526158e-08
*cbd_15 128 11 0
*cbs_15 129 11 0
*rd_15 9 128 0
*rs_15 11 129 0

* compensation capacitors

Cc1 4 10 5p

Cc2 7 10 12p

Rc 10 12 600

*Vdd 11 0  dc 2.8

Vi 14 0 dc 1.4 ac 1

C2 13 0 1g

L1 13 12 1g

* load capacitor

Cl 12 0 30p

*extra control information--------------

.options post=2

.op

.ac dec 10 1 100meg

*.print ac VDB(12) VP(12)
.print ac Vm(12)

.END
